v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {title.sym} -4270 -70 0 0 {name=l1 author="Andrés Martínez"}
