v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {title.sym} -4260 -330 0 0 {name=l1 author="Prof: Jorge Marín , Ayudante: Andrés Martínez"}
