v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -4380 -1340 -3220 -1340 {}
T {IPD413 - "Seminario Avanzado de Electrónica Industrial"
=> "Diseño de circuitos integrados Analogicos"} -4380 -1450 0 0 0.8 0.8 {}
C {title.sym} -4310 -1240 0 0 {name=l1 author="Prof: Jorge Marín , Ayudante: Andrés Martínez"}
