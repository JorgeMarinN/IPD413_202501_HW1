v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {title.sym} -4230 -500 0 0 {name=l1 author="Prof: Jorge Marín , Ayudante: Andrés Martínez"}
C {../Tareas/Tarea_1/Tarea_1.sym} -4100 -610 0 0 {name=X1}
C {../Tareas/Tarea_2/Tarea_2.sym} -4100 -560 0 0 {name=X2}
C {../Tareas/Tarea_3/Tarea_3.sym} -4100 -510 0 0 {name=X3}
