v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {title.sym} -4220 -530 0 0 {name=l1 author="Prof: Jorge Marín , Ayudante: Andrés Martínez"}
C {../Tarea_1/nmoslv_charac_IPD413-202501-HW1.sym} -3930 -590 0 0 {name=X1}
C {../Tarea_1/nmoslv_instrinsic_gain_IPD413-202501-HW1.sym} -3930 -540 0 0 {name=X2}
