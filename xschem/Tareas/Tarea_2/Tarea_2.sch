v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -4300 -330 -4300 -120 {}
C {title.sym} -4270 -70 0 0 {name=l1 author="Andrés Martínez"}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA1_OL_IPD413_202501_HW2.sym} -4130 -240 0 0 {name=X1}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA2_OL_IPD413_202501_HW2.sym} -4130 -190 0 0 {name=X2}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA2_CL_IPD413_202501_HW2.sym} -4130 -140 0 0 {name=X3}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA2_StepResp_IPD413_202501_HW2.sym} -4130 -90 0 0 {name=X4}
