v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -4290 -400 -4290 -190 {}
L 4 -4000 -400 -4000 -180 {}
L 4 -3680 -400 -3680 -180 {}
L 4 -4290 -400 -3680 -400 {}
L 4 -4290 -180 -3680 -180 {}
L 4 -4290 -190 -4290 -180 {}
L 4 -4290 -350 -3680 -350 {}
T {OTA1} -4190 -390 0 0 0.6 0.6 {}
T {OTA Miller} -3930 -390 0 0 0.6 0.6 {}
C {title.sym} -4270 -70 0 0 {name=l1 author="Andrés Martínez"}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA1_OL_IPD413_202501_HW2.sym} -4130 -240 0 0 {name=X1}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA2_OL_IPD413_202501_HW2.sym} -3830 -240 0 0 {name=X2}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA2_CL_IPD413_202501_HW2.sym} -3830 -190 0 0 {name=X3}
C {/workspaces/usm-vlsi-tools/shared_xserver/simulations/Projects/IHP/IPD413_202501/xschem/Tareas/Tarea_2/TB_OTA2_StepResp_IPD413_202501_HW2.sym} -3830 -140 0 0 {name=X4}
